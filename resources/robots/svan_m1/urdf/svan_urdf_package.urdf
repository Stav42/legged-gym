Commit message: plots done

File: resources/robots/svan_m1/urdf/svan_urdf_package.urdf (robot description, URDF)
Before this commit: robot svan_urdf_package, 18 links, 17 joints
Joints:
- joint rr_abd_j: axis 1 0 0 -> -1 0 0
- joint rr_hip_j: axis 0 1 0 -> 0 -1 0
